# IAR project OS3-TCPIP-HTTPc-No-Source.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; NDEBUG
  ICCARM.CCIncludePath2: ..\; ..\..\BSP; ..\..\BSP\OS\uCOS-III; ..\..\BSP\TCPIP; ..\..\BSP\ST\STM32F4xx\inc; ..\..\..\..\..\Software\uC-CPU; ..\..\..\..\..\Software\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\..\Software\uC-LIB; ..\..\..\..\..\Software\uCOS-III; ..\..\..\..\..\Software\uCOS-III\Source; ..\..\..\..\..\Software\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\..\..\..\Software\uC-Serial\Driver\ST; ..\..\..\..\..\Software\uC-Serial\Driver\ST\STM3240x; ..\..\..\..\..\Software\uC-Serial\Line; ..\..\..\..\..\Software\uC-Serial\OS; ..\..\..\..\..\Software\uC-Serial\Source; ..\..\..\..\..\Software\uC-Common; ..\..\..\..\..\Software\uC-Common\KAL; ..\..\..\..\..\Software\uC-Common\KAL\uCOS-III; ..\..\..\..\..\Software\uC-TCPIP; ..\..\..\..\..\Software\uC-TCPIP\Source; ..\..\..\..\..\Software\uC-TCPIP\IP\IPv4; ..\..\..\..\..\Software\uC-TCPIP\IP\IPv6; ..\..\..\..\..\Software\uC-TCPIP\IF; ..\..\..\..\..\Software\uC-TCPIP\Dev\Ether\PHY\Generic; ..\..\..\..\..\Software\uC-TCPIP\Dev\Ether\GMAC; ../../../../../Software/uC-DHCPc; ../../../../../Software/uC-DHCPc/Source; ../../../../../Software/uC-DNSc; ../../../../../Software/uC-DNSc\Source; ../../../../../Software/uC-HTTP; ../../../../../Software/uC-Trace; ../../../../../Software/uC-Trace/Recorders/Percepio/OS/uCOS-III; ../../../../../Software/uC-Trace/Recorders/Percepio/TraceRecorderLibrary/Include; ../../../../../Software/uC-Trace/Recorders/Percepio/TraceRecorderLibrary/KernelPorts/uCOS-III
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OS.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\BSP\IAR\STM32F4xx_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h stm32f4xx.h stm32f4xx_conf.h
  group APP/DHCP
    ../: dhcp-c_cfg.h
  group APP/DNS
    ../: app_dns-c.c app_dns-c.h dns-c_cfg.c dns-c_cfg.h
  group APP/HTTP
    ../: http-c_app.c http-c_app.h http-c_cfg.c http-c_cfg.h http-c_hooks.c http-c_hooks.h
  group APP/Library
    ../: OS3-TCPIP-HTTPc-DNSc-DHCPc-Trace-Library.a
  group APP/TCPIP
    ../: app_tcpip.c app_tcpip.h net_cfg.c net_cfg.h net_dev_cfg.c net_dev_cfg.h
  group APP/Trace
    ../: trace_cfg.c trace_cfg.h trcConfig.h trcHardwarePort.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c
  group BSP/IAR
    ../../BSP/IAR/: cstartup.c STM32F4xx_FLASH.icf
  group BSP/OS/uCOS-III
    ../../BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
  group BSP/ST/STM32F4xx/inc
    ../../BSP/ST/STM32F4xx/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group BSP/ST/STM32F4xx/src
    ../../BSP/ST/STM32F4xx/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group BSP/TCPIP
    ../../BSP/TCPIP/: net_bsp.c net_bsp.h
  group uC-HTTP/Client/Source
    ../../../../../Software/uC-HTTP/Client/Source/: http-c.h http-c_conn.h http-c_req.h http-c_resp.h http-c_sock.h http-c_task.h http-c_type.h
  group uC-HTTP/Common
    ../../../../../Software/uC-HTTP/Common/: http.h
  group uC/Common/KAL
    ../../../../../Software/uC-Common/KAL/: kal.h
  group uC/Common/KAL/uCOS-III
    ../../../../../Software/uC-Common/KAL/uCOS-III/: kal.c
  group uC/CPU
    ../../../../../Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/ARM-Cortex-M4/IAR
    ../../../../../Software/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC/DHCPc/Source
    ../../../../../Software/uC-DHCPc/Source/: dhcp-c.h
  group uC/DNSc/Source
    ../../../../../Software/uC-DNSc/Source/: dns-c.h dns-c_cache.h dns-c_req.h dns-c_task.h dns-c_type.h
  group uC/LIB
    ../../../../../Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports/ARM-Cortex-M4/IAR
    ../../../../../Software/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC/OS-III/Ports/ARM-Cortex-M4/Generic/IAR
    ../../../../../Software/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III/Source
    ../../../../../Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/TCPIP/Dev/Ether/GMAC
    ../../../../../Software/uC-TCPIP/Dev/Ether/GMAC/: net_dev_gmac.h
  group uC/TCPIP/Dev/Ether/PHY/Generic
    ../../../../../Software/uC-TCPIP/Dev/Ether/PHY/Generic/: net_phy.h
  group uC/TCPIP/IF
    ../../../../../Software/uC-TCPIP/IF/: net_if.h net_if_802x.h net_if_ether.h net_if_loopback.h
  group uC/TCPIP/IP/IPv4
    ../../../../../Software/uC-TCPIP/IP/IPv4/: net_arp.h net_icmpv4.h net_igmp.h net_ipv4.h
  group uC/TCPIP/IP/IPv6
    ../../../../../Software/uC-TCPIP/IP/IPv6/: net_icmpv6.h net_ipv6.h net_mldp.h net_ndp.h
  group uC/TCPIP/Source
    ../../../../../Software/uC-TCPIP/Source/: net.h net_app.h net_ascii.h net_bsd.h net_buf.h net_cache.h net_cfg_net.h net_conn.h net_ctr.h net_def.h net_err.h net_icmp.h net_ip.h net_mgr.h net_sock.h net_stat.h net_tcp.h net_tmr.h net_type.h net_udp.h net_util.h
  group uC/Trace/Source
    ../../../../../Software/uC-Trace/Source/: trace.h
